<?xml version='1.0' encoding='utf-8'?>

<AUTOSAR>
<OS>
<General Comment="*" ErrorHook="ErrorHook" PostTaskHook="PostTaskHook" PreTaskHook="PreTaskHook" ProtectionHook="NULL" ShutdownHook="ShutdownHook" StartupHook="StartupHook" />
<TaskList Max="TBD" />
<AlarmList Max="TBD" />
<CounterList Max="TBD" />
<ResourceList Max="TBD" />
</OS>
<EcuC>
<PduList Max="TBD">
<Pdu Comment="*" Name="TxDiagP2P" Size="64" />
<Pdu Comment="*" Name="RxDiagP2P" Size="64" />
</PduList>
</EcuC>
<Can>
<General Comment="*" DevelopmentErrorDetection="ON" VersionInfoApi="ON" />
<ControllerList Max="TBD">
<Controller Baudrate="1000" Comment="*" Name="CAN_CTRL_1" Seg1="13" Seg2="2">
<HohList Max="TBD">
<Hoh Comment="*" HohType="BASIC" IdentifierType="STANDARD" Name="Can1Hrh" ObjectType="RECEIVE" />
<Hoh Comment="*" HohType="BASIC" IdentifierType="STANDARD" Name="Can1Hth" ObjectType="TRANSMIT" />
</HohList>
</Controller>
</ControllerList>
</Can>
<CanIf>
<General BusOffNotification="NULL" Comment="*" DataLengthCodeCheck="ON" DevelopmentErrorDetection="ON" ErrorNotification="NULL" RxFifoSize="32" TaskFifoMode="ON" TxFifoSize="32" VersionInfoApi="OFF" />
<ChannelList Max="TBD">
<Channel Comment="*" ControllerRef="CAN_CTRL_1" Name="CANIF_CHL_LS">
<HthList Max="TBD">
<Hth Comment="*" HthRef="Can1Hth" Name="LS_Hth">
<PduList Max="TBD">
<Pdu Comment="*" DataLengthCode="8" EcuCPduRef="TxDiagP2P" Identifier="0x732" Name="P2P" TransmitNotifier="CanTp" UserNotification="CanIf_UserTxConfirmation" />
</PduList>
</Hth>
</HthList>
<HrhList Max="TBD">
<Hrh Comment="*" HrhRef="Can1Hrh" Name="LS_Hrh" SoftwareFilterUsed="True">
<PduList Max="TBD">
<Pdu Comment="*" DataLengthCode="8" EcuCPduRef="RxDiagP2P" FilterMask="0xFFF" Identifier="0x731" Name="P2P" ReceivedNotifier="CanTp" UserNotification="CanIf_UserRxIndication" />
</PduList>
</Hrh>
</HrhList>
</Channel>
</ChannelList>
</CanIf>
<CanTp>
<General Comment="*" DevelopmentErrorDetection="ON" VersionInfoApi="OFF" />
<RxSduList Max="TBD">
<Sdu BS="8" Comment="*" CommunicationType="PHYSICAL" MaxBusyTransmission="10" Name="SduP2P" Nar="25" Nbr="25" Ncr="150" Padding="ON" RxPduRef="RxDiagP2P" STmin="1" TxFcPduRef="TxDiagP2P" />
</RxSduList>
<TxSduList Max="TBD">
<Sdu Comment="*" CommunicationType="PHYSICAL" Name="SduP2P" Nas="25" Nbs="75" Ncs="25" Padding="ON" RxFcPduRef="RxDiagP2P" TxPduRef="TxDiagP2P" />
</TxSduList>
</CanTp>
<PduR>
<General CanIfUsed="False" CanTpUsed="True" ComUsed="False" Comment="*" DcmUsed="True" DevelopmentErrorDetection="ON" J1939TpUsed="False" LinIfUsed="False" LinTpUsed="False" VersionInfoApi="OFF" ZeroCostIf="CanIf" ZeroCostOperationMode="ON" ZeroCostTp="CanTp" />
<RoutineList Max="TBD">
<Source Comment="*" Module="Dcm" Name="DcmP2P" PduRef="TxDiagP2P">
<DestinationList Max="TBD">
<Destination Comment="*" Module="CanTp" Name="CanTpP2P" PduRef="TxDiagP2P" />
</DestinationList>
</Source>
<Source Comment="*" Module="CanTp" Name="CanTpP2P" PduRef="RxDiagP2P">
<DestinationList Max="TBD">
<Destination Comment="*" Module="Dcm" Name="DcmP2P" PduRef="RxDiagP2P" />
</DestinationList>
</Source>
</RoutineList>
</PduR>
<Com>
<General Comment="*" DevelopmentErrorDetection="ON" VersionInfoApi="OFF" />
<PduGroupList Max="TBD" />
<IPduList Max="TBD" />
</Com>
<Dcm>
<General Comment="*" DevelopmentErrorDetection="ON" MaxPeriodDIDNumber="8" PeriodicDIDFastModeTime="50" PeriodicDIDMediumModeTime="100" PeriodicDIDSlowModeTime="200" VersionInfoApi="OFF" />
<BufferList Max="TBD">
<Buffer Comment="rx buffer" Name="Buffer1" Size="4096" />
<Buffer Comment="tx buffer" Name="Buffer2" Size="512" />
</BufferList>
<SessionList Max="TBD">
<Session Comment="*" Identifier="1" Name="DS" P2ServerMaxTimeMs="100" P2StartServerMaxTimeMs="100" />
<Session Comment="*" Identifier="2" Name="PRGS" P2ServerMaxTimeMs="100" P2StartServerMaxTimeMs="100" />
<Session Comment="*" Identifier="3" Name="EXTDS" P2ServerMaxTimeMs="100" P2StartServerMaxTimeMs="100" />
</SessionList>
<SecurityList Max="TBD">
<Security Comment="*" CompareKeyCallback="BL_CompareProgramSessionSeed" GetSeedCallback="BL_GetProgramSessionSeed" Identifier="2" KeySize="4" Name="PRGS" SeedSize="4" />
<Security Comment="*" CompareKeyCallback="BL_CompareExtendedSessionSeed" GetSeedCallback="BL_GetExtendedSessionSeed" Identifier="1" KeySize="4" Name="EXTDS" SeedSize="4" />
<Security Comment="Level 0, is the default for each session when enterred" CompareKeyCallback="NULL" GetSeedCallback="NULL" Identifier="0" KeySize="4" Name="Default" SeedSize="4" />
</SecurityList>
<DIDControlRecordList Max="TBD" />
<DIDInfoList Max="TBD" />
<DIDList Max="TBD" />
<RoutineInfoList Max="TBD">
<RoutineInfo Comment="*" Name="RoutineInfo_EraseFlash">
<SessionList Max="TBD">
<Session Comment="*" Name="PRGS" />
</SessionList>
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
<Start Comment="4 byte address, 4 byte size, 1 byte identifier" RecordSizeOfRequest="9" RecordSizeOfResponse="0" />
</RoutineInfo>
<RoutineInfo Comment="*" Name="RoutineInfo_TestJumpToApplication">
<SessionList Max="TBD">
<Session Comment="*" Name="PRGS" />
</SessionList>
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
<Start Comment="direct jump to application and no response" RecordSizeOfRequest="0" RecordSizeOfResponse="0" />
</RoutineInfo>
</RoutineInfoList>
<RoutineList Max="TBD">
<Routine Comment="*" Identifier="0xFF01" Name="EraseFlash" RoutineInfoRef="RoutineInfo_EraseFlash" RoutineResultCbk="NULL" StartRoutineCbk="BL_StartEraseFlash" StopRoutineCbk="NULL" />
<Routine Comment="*" Identifier="0xFF03" Name="TestJumpToApplication" RoutineInfoRef="RoutineInfo_TestJumpToApplication" RoutineResultCbk="NULL" StartRoutineCbk="BL_TestJumpToApplicatin" StopRoutineCbk="NULL" />
</RoutineList>
<MemoryList Max="TBD">
<Memory Comment="*" Identifier="0xFF" Name="Flash">
<MemoryReadInfoList Max="TBD">
<MemoryInfo AddressHigh="0x00010000" AddressLow="0x00000000" Comment="0~64K for bootloader" Name="Bootloader">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
</MemoryInfo>
<MemoryInfo AddressHigh="0x00040000" AddressLow="0x00010000" Comment="64K~256K for application" Name="Application">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
</MemoryInfo>
</MemoryReadInfoList>
<MemoryWriteInfoList Max="TBD">
<MemoryInfo AddressHigh="0x00040000" AddressLow="0x00010000" Comment="*" Name="Application">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
</MemoryInfo>
</MemoryWriteInfoList>
</Memory>
<Memory Comment="*" Identifier="0xEE" Name="Eeprom">
<MemoryReadInfoList Max="TBD">
<MemoryInfo AddressHigh="256" AddressLow="0" Comment="0~256 for bootloader information storage" Name="Bootloader">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
</MemoryInfo>
<MemoryInfo AddressHigh="4096" AddressLow="256" Comment="*" Name="Application">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
</MemoryInfo>
</MemoryReadInfoList>
<MemoryWriteInfoList Max="TBD">
<MemoryInfo AddressHigh="256" AddressLow="0" Comment="*" Name="Bootloader">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
</MemoryInfo>
<MemoryInfo AddressHigh="4096" AddressLow="256" Comment="*" Name="Application">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
</MemoryInfo>
</MemoryWriteInfoList>
</Memory>
<Memory Comment="*" Identifier="0xFD" Name="FlashDriver">
<MemoryReadInfoList Max="TBD">
<MemoryInfo AddressHigh="4096" AddressLow="0" Comment="*" Name="FlashDriver">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
</MemoryInfo>
</MemoryReadInfoList>
<MemoryWriteInfoList Max="TBD">
<MemoryInfo AddressHigh="4096" AddressLow="0" Comment="*" Name="FlashDriver">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
</MemoryInfo>
</MemoryWriteInfoList>
</Memory>
</MemoryList>
<ProtocolList Max="TBD">
<Protocol Comment="*" Name="P2P" ProtocolID="UDS_ON_CAN" RxBufferRef="Buffer1" ServiceTableRef="ServiceTable1" TimingLimitRef="Timing1" TransmissionType="TYPE_1" TxBufferRef="Buffer2">
<ConnectionList Max="TBD">
<Connection Comment="*" Name="Connection1">
<RxChannelList Max="TBD">
<RxChannel AddressingType="PHYSICAL" Comment="*" Name="RxChannel1" PduRef="RxDiagP2P" />
</RxChannelList>
<TxChannel Comment="*" Name="TxChannel2" PduRef="TxDiagP2P" />
</Connection>
</ConnectionList>
</Protocol>
</ProtocolList>
<RequestServiceList Max="TBD">
<RequestService Comment="*" Name="RequestService1" ProtocolIndicationCbk="BL_ProtocolIndicationCbk" StartProtocolCbk="BL_StartProtocolCbk" StopProtocolCbk="BL_StopProtocolCbk" />
</RequestServiceList>
<ServiceTableList Max="TBD">
<ServiceTable Comment="*" Name="ServiceTable1">
<ServiceList Max="TBD">
<Service Comment="*" Name="DIAGNOSTIC_SESSION_CONTROL" SubFunctionSupported="True">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
<Security Comment="*" Name="EXTDS" />
<Security Comment="*" Name="Default" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="DS" />
<Session Comment="*" Name="PRGS" />
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
<Service Comment="*" Name="SECURITY_ACCESS" SubFunctionSupported="True">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
<Security Comment="*" Name="EXTDS" />
<Security Comment="*" Name="Default" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="PRGS" />
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
<Service Comment="*" Name="TESTER_PRESENT" SubFunctionSupported="True">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
<Security Comment="*" Name="EXTDS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="PRGS" />
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
<Service Comment="*" Name="ROUTINE_CONTROL" SubFunctionSupported="True">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
<Security Comment="*" Name="EXTDS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="PRGS" />
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
<Service Comment="*" Name="ECU_RESET" SubFunctionSupported="True">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
<Security Comment="*" Name="EXTDS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="PRGS" />
<Session Comment="*" Name="EXTDS" />
</SessionList>
</Service>
<Service Comment="*" Name="REQUEST_DOWNLOAD" SubFunctionSupported="False">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="PRGS" />
</SessionList>
</Service>
<Service Comment="*" Name="REQUEST_UPLOAD" SubFunctionSupported="False">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="PRGS" />
</SessionList>
</Service>
<Service Comment="*" Name="TRANSFER_DATA" SubFunctionSupported="False">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="PRGS" />
</SessionList>
</Service>
<Service Comment="*" Name="REQUEST_TRANSFER_EXIT" SubFunctionSupported="False">
<SecurityList Max="TBD">
<Security Comment="*" Name="PRGS" />
</SecurityList>
<SessionList Max="TBD">
<Session Comment="*" Name="PRGS" />
</SessionList>
</Service>
</ServiceList>
</ServiceTable>
</ServiceTableList>
<SessionControlList Max="TBD">
<SessionControl Comment="*" GetSessionChangePermissionCbk="BL_GetSessionChangePermission" Name="SessionControl" />
</SessionControlList>
<TimingList Max="TBD">
<Timing Comment="*" Name="Timing1" P2ServerMaxTimeMs="100" P2ServerMinTimeMs="20" S3ServerTimeMs="5000" />
</TimingList>
</Dcm>
<Fls>
<General Comment="*" DevelopmentErrorDetection="OFF" FlashBaseAddress="0" MaxFastReadSize="512" MaxFastWriteSize="32" MaxNormalReadSize="32" MaxNormalWriteSize="8" VersionInfoApi="OFF" />
<SectorList Max="TBD" />
</Fls>
<Fee>
<General Comment="*" DevelopmentErrorDetection="OFF" NvmJobEndNotification="NULL" NvmJobErrorNotification="NULL" PollingMode="ON" VersionInfoApi="OFF" VirtualPageSize="8" />
<BlockList Max="TBD" />
</Fee>
<Ea>
<General Comment="*" DevelopmentErrorDetection="OFF" NvmJobEndNotification="NULL" NvmJobErrorNotification="NULL" SetModeApi="ON" VersionInfoApi="OFF" VirtualPageSize="8" />
<BlockList Max="TBD" />
</Ea>
<NvM>
<General Comment="*" ConfigClass="CLASS_2" DevelopmentErrorDetection="OFF" ImmediateJobQueueSize="8" MultiBlockCallback="NULL" PollingMode="ON" RamBlockStatusApi="ON" StandardJobQueueSize="8" VersionInfoApi="OFF" />
<BlockList Max="TBD" />
</NvM>
</AUTOSAR>
