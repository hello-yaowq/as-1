<?xml version='1.0' encoding='utf-8'?>
<AUTOSAR><OS><General Comment="*" ErrorHook="ErrorHook" PostTaskHook="PostTaskHook" PreTaskHook="PreTaskHook" ProtectionHook="NULL" ShutdownHook="ShutdownHook" StartupHook="StartupHook" /><TaskList Max="TBD" /><AlarmList Max="TBD" /><CounterList Max="TBD" /><ResourceList Max="TBD" /></OS><EcuC><PduList Max="TBD"><Pdu Comment="*" Name="TxDiagP2P" Size="64" /><Pdu Comment="*" Name="RxDiagP2P" Size="64" /><Pdu Comment="*" Name="TxDiagP2A" Size="64" /><Pdu Comment="*" Name="RxDiagP2A" Size="64" /></PduList></EcuC><Can><General Comment="*" DevelopmentErrorDetection="ON" VersionInfoApi="ON" /><ControllerList Max="TBD"><Controller Baudrate="1000" Comment="*" Name="CAN_CTRL_1" Seg1="13" Seg2="2"><HohList Max="TBD"><Hoh Comment="*" HohType="BASIC" IdentifierType="STANDARD" Name="Can1Hrh" ObjectType="RECEIVE" /><Hoh Comment="*" HohType="BASIC" IdentifierType="STANDARD" Name="Can1Hth" ObjectType="TRANSMIT" /></HohList></Controller></ControllerList></Can><CanIf><General BusOffNotification="NULL" Comment="*" DataLengthCodeCheck="ON" DevelopmentErrorDetection="ON" ErrorNotification="NULL" VersionInfoApi="OFF" /><ChannelList Max="TBD"><Channel Comment="*" ControllerRef="CAN_CTRL_1" Name="CANIF_CHL_LS"><HthList Max="TBD"><Hth Comment="*" HthRef="Can1Hth" Name="LS_Hth"><PduList Max="TBD"><Pdu Comment="*" DataLengthCode="8" EcuCPduRef="TxDiagP2P" Identifier="0x732" Name="P2P" TransmitNotifier="CanTp" UserNotification="CanIf_UserTxConfirmation" /><Pdu Comment="*" DataLengthCode="8" EcuCPduRef="TxDiagP2A" Identifier="0x742" Name="P2A" TransmitNotifier="CanTp" UserNotification="CanIf_UserTxConfirmation" /></PduList></Hth></HthList><HrhList Max="TBD"><Hrh Comment="*" HrhRef="Can1Hrh" Name="LS_Hrh" SoftwareFilterUsed="True"><PduList Max="TBD"><Pdu Comment="*" DataLengthCode="8" EcuCPduRef="RxDiagP2P" FilterMask="0xFFF" Identifier="0x731" Name="P2P" ReceivedNotifier="CanTp" UserNotification="CanIf_UserRxIndication" /><Pdu Comment="*" DataLengthCode="8" EcuCPduRef="RxDiagP2A" FilterMask="0xFFF" Identifier="0x741" Name="P2A" ReceivedNotifier="CanTp" UserNotification="CanIf_UserRxIndication" /></PduList></Hrh></HrhList></Channel></ChannelList></CanIf><CanTp><General Comment="*" DevelopmentErrorDetection="ON" VersionInfoApi="OFF" /><RxSduList Max="TBD"><Sdu BS="8" Comment="*" CommunicationType="PHYSICAL" MaxBusyTransmission="10" Name="SduP2P" Nar="100" Nbr="100" Ncr="100" Padding="ON" RxPduRef="RxDiagP2P" STmin="1" TxFcPduRef="TxDiagP2P" /><Sdu BS="8" Comment="*" CommunicationType="PHYSICAL" MaxBusyTransmission="10" Name="SduP2A" Nar="100" Nbr="100" Ncr="100" Padding="ON" RxPduRef="RxDiagP2A" STmin="1" TxFcPduRef="TxDiagP2A" /></RxSduList><TxSduList Max="TBD"><Sdu Comment="*" CommunicationType="PHYSICAL" Name="SduP2P" Nas="100" Nbs="100" Ncs="100" Padding="ON" RxFcPduRef="RxDiagP2P" TxPduRef="TxDiagP2P" /><Sdu Comment="*" CommunicationType="PHYSICAL" Name="SduP2A" Nas="100" Nbs="100" Ncs="100" Padding="ON" RxFcPduRef="RxDiagP2A" TxPduRef="TxDiagP2A" /></TxSduList></CanTp><PduR><General CanIfUsed="False" CanTpUsed="True" ComUsed="False" Comment="*" DcmUsed="True" DevelopmentErrorDetection="ON" J1939TpUsed="False" LinIfUsed="False" LinTpUsed="False" VersionInfoApi="OFF" ZeroCostIf="CanIf" ZeroCostOperationMode="ON" ZeroCostTp="CanTp" /><RoutineList Max="TBD"><Source Comment="*" Module="Dcm" Name="DcmP2P" PduRef="TxDiagP2P"><DestinationList Max="TBD"><Destination Comment="*" Module="CanTp" Name="CanTpP2P" PduRef="TxDiagP2P" /></DestinationList></Source><Source Comment="*" Module="CanTp" Name="CanTpP2P" PduRef="RxDiagP2P"><DestinationList Max="TBD"><Destination Comment="*" Module="Dcm" Name="DcmP2P" PduRef="RxDiagP2P" /></DestinationList></Source><Source Comment="*" Module="Dcm" Name="DcmP2A" PduRef="TxDiagP2A"><DestinationList Max="TBD"><Destination Comment="*" Module="CanTp" Name="CanTpP2A" PduRef="TxDiagP2A" /></DestinationList></Source><Source Comment="*" Module="CanTp" Name="CanTpP2A" PduRef="RxDiagP2A"><DestinationList Max="TBD"><Destination Comment="*" Module="Dcm" Name="DcmP2A" PduRef="RxDiagP2A" /></DestinationList></Source></RoutineList></PduR><Com><General Comment="*" DevelopmentErrorDetection="ON" VersionInfoApi="OFF" /><PduGroupList Max="TBD" /><IPduList Max="TBD" /></Com><Dcm><General Comment="*" DevelopmentErrorDetection="ON" MaxPeriodDIDNumber="8" PeriodicDIDFastModeTime="50" PeriodicDIDMediumModeTime="100" PeriodicDIDSlowModeTime="200" VersionInfoApi="OFF" /><BufferList Max="TBD"><Buffer Comment="*" Name="Buffer1" Size="512" /><Buffer Comment="*" Name="Buffer2" Size="512" /><Buffer Comment="*" Name="Buffer3" Size="512" /><Buffer Comment="*" Name="Buffer4" Size="512" /></BufferList><SessionList Max="TBD"><Session Comment="*" Identifier="1" Name="DS" P2ServerMaxTimeMs="5000" P2StartServerMaxTimeMs="500" /><Session Comment="*" Identifier="2" Name="PRGS" P2ServerMaxTimeMs="5000" P2StartServerMaxTimeMs="500" /><Session Comment="*" Identifier="3" Name="EXTDS" P2ServerMaxTimeMs="5000" P2StartServerMaxTimeMs="500" /></SessionList><SecurityList Max="TBD"><Security Comment="*" CompareKeyCallback="BL_CompareProgramSessionSeed" GetSeedCallback="BL_GetProgramSessionSeed" Identifier="6" KeySize="4" Name="PRGS" SeedSize="4" /><Security Comment="*" CompareKeyCallback="BL_CompareExtendedSessionSeed" GetSeedCallback="BL_GetExtendedSessionSeed" Identifier="7" KeySize="4" Name="EXTDS" SeedSize="4" /><Security Comment="Level 0, is the default for each session when enterred" CompareKeyCallback="NULL" GetSeedCallback="NULL" Identifier="0" KeySize="4" Name="Default" SeedSize="4" /></SecurityList><DIDControlRecordList Max="TBD" /><DIDInfoList Max="TBD" /><DIDList Max="TBD" /><RoutineInfoList Max="TBD"><RoutineInfo Comment="*" Name="RoutineInfo_EraseFlash"><SecurityList Max="TBD"><Security Comment="*" Name="PRGS" /></SecurityList><Start Comment="4 byte address, 4 byte size" RecordSizeOfRequest="8" RecordSizeOfResponse="0" /><Result Comment="*" RecordSizeOfResponse="1" /></RoutineInfo></RoutineInfoList><RoutineList Max="TBD"><Routine Comment="*" Identifier="0xFF01" Name="EraseFlash" RoutineInfoRef="RoutineInfo_EraseFlash" RoutineResultCbk="BL_GetEraseFlashResult" StartRoutineCbk="BL_StartEraseFlash" StopRoutineCbk="NULL" /></RoutineList><MemoryList Max="TBD" /><ProtocolList Max="TBD"><Protocol Comment="*" Name="P2P" ProtocolID="UDS_ON_CAN" RxBufferRef="Buffer1" ServiceTableRef="ServiceTable1" TimingLimitRef="Timing1" TransmissionType="TYPE_1" TxBufferRef="Buffer2"><ConnectionList Max="TBD"><Connection Comment="*" Name="Connection1"><RxChannelList Max="TBD"><RxChannel AddressingType="PHYSICAL" Comment="*" Name="RxChannel1" PduRef="RxDiagP2P" /></RxChannelList><TxChannel Comment="*" Name="TxChannel2" PduRef="TxDiagP2P" /></Connection></ConnectionList></Protocol><Protocol Comment="*" Name="P2A" ProtocolID="UDS_ON_CAN" RxBufferRef="Buffer3" ServiceTableRef="ServiceTable1" TimingLimitRef="Timing1" TransmissionType="TYPE_1" TxBufferRef="Buffer4"><ConnectionList Max="TBD"><Connection Comment="*" Name="Connection1"><RxChannelList Max="TBD"><RxChannel AddressingType="PHYSICAL" Comment="*" Name="RxChannel1" PduRef="RxDiagP2A" /></RxChannelList><TxChannel Comment="*" Name="TxChannel2" PduRef="TxDiagP2A" /></Connection></ConnectionList></Protocol></ProtocolList><RequestServiceList Max="TBD"><RequestService Comment="*" Name="RequestService1" ProtocolIndicationCbk="BL_ProtocolIndicationCbk" StartProtocolCbk="BL_StartProtocolCbk" StopProtocolCbk="BL_StopProtocolCbk" /></RequestServiceList><ServiceTableList Max="TBD"><ServiceTable Comment="*" Name="ServiceTable1"><ServiceList Max="TBD"><Service Comment="*" Name="DIAGNOSTIC_SESSION_CONTROL" SubFunctionSupported="True"><SecurityList Max="TBD"><Security Comment="*" Name="PRGS" /><Security Comment="*" Name="EXTDS" /></SecurityList><SessionList Max="TBD"><Session Comment="*" Name="DS" /><Session Comment="*" Name="PRGS" /><Session Comment="*" Name="EXTDS" /></SessionList></Service><Service Comment="*" Name="SECURITY_ACCESS" SubFunctionSupported="True"><SecurityList Max="TBD"><Security Comment="*" Name="PRGS" /><Security Comment="*" Name="EXTDS" /></SecurityList><SessionList Max="TBD"><Session Comment="*" Name="PRGS" /><Session Comment="*" Name="EXTDS" /></SessionList></Service><Service Comment="*" Name="TESTER_PRESENT" SubFunctionSupported="True"><SecurityList Max="TBD"><Security Comment="*" Name="PRGS" /><Security Comment="*" Name="EXTDS" /></SecurityList><SessionList Max="TBD"><Session Comment="*" Name="PRGS" /><Session Comment="*" Name="EXTDS" /></SessionList></Service><Service Comment="*" Name="READ_DATA_BY_IDENTIFIER" SubFunctionSupported="False"><SecurityList Max="TBD"><Security Comment="*" Name="PRGS" /><Security Comment="*" Name="EXTDS" /></SecurityList><SessionList Max="TBD"><Session Comment="*" Name="PRGS" /><Session Comment="*" Name="EXTDS" /></SessionList></Service><Service Comment="*" Name="ROUTINE_CONTROL" SubFunctionSupported="True"><SecurityList Max="TBD"><Security Comment="*" Name="PRGS" /><Security Comment="*" Name="EXTDS" /></SecurityList><SessionList Max="TBD"><Session Comment="*" Name="PRGS" /><Session Comment="*" Name="EXTDS" /></SessionList></Service><Service Comment="*" Name="WRITE_DATA_BY_IDENTIFIER" SubFunctionSupported="False"><SecurityList Max="TBD"><Security Comment="*" Name="PRGS" /><Security Comment="*" Name="EXTDS" /></SecurityList><SessionList Max="TBD"><Session Comment="*" Name="PRGS" /><Session Comment="*" Name="EXTDS" /></SessionList></Service><Service Comment="*" Name="INPUT_OUTPUT_CONTROL_BY_IDENTIFIER" SubFunctionSupported="True"><SecurityList Max="TBD"><Security Comment="*" Name="PRGS" /><Security Comment="*" Name="EXTDS" /></SecurityList><SessionList Max="TBD"><Session Comment="*" Name="PRGS" /><Session Comment="*" Name="EXTDS" /></SessionList></Service><Service Comment="*" Name="ECU_RESET" SubFunctionSupported="True"><SecurityList Max="TBD"><Security Comment="*" Name="PRGS" /><Security Comment="*" Name="EXTDS" /></SecurityList><SessionList Max="TBD"><Session Comment="*" Name="PRGS" /><Session Comment="*" Name="EXTDS" /></SessionList></Service></ServiceList></ServiceTable></ServiceTableList><SessionControlList Max="TBD"><SessionControl Comment="*" GetSessionChangePermissionCbk="BL_GetSessionChangePermission" Name="SessionControl" /></SessionControlList><TimingList Max="TBD"><Timing Comment="*" Name="Timing1" P2ServerMaxTimeMs="5000" P2ServerMinTimeMs="3000" S3ServerTimeMs="10000" /></TimingList></Dcm></AUTOSAR>