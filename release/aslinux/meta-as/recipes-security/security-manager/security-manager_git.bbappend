

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
   file://0001-Fix-build-error-of-security-manager.patch \
"

